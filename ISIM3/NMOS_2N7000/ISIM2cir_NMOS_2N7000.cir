** DC circuit - 2 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: mizra
* Wed, Mar 15, 2023 14:36:13
*

*## Multisim Component 0_5V_PWR ##*
v0_5V_PWR VpwrPin 0 dc {EpwrPinParam} ac 0 0

*## Multisim Component DAC1 ##*
vDAC1 VDAC1 0 dc {DAC1Param} ac 0 0

*## Multisim Component DUT ##*
xDUT Collector base Emitter 2N7000_2__MOS_ENH_N__1

*## Multisim Component DigCVin10 ##*
vDigCVin10 CVin10 0 dc {DigCVin10Param} ac 0 0

*## Multisim Component DigCVin1k ##*
vDigCVin1k CVin1k 0 dc {DigCVin1kParam} ac 0 0

*## Multisim Component RB100 ##*
rRB100 VDAC1mult base 100

*## Multisim Component V15 ##*
vV15 -5V 0 dc -5 ac 0 0

*## Multisim Component V14 ##*
vV14 12V 0 dc 12 ac 0 0

*## Multisim Component DAC0 ##*
vDAC0 VDAC0 0 dc {DAC0Param} ac 0 0

*## Multisim Component RC10 ##*
rRC10 CRes10 Collector 10

*## Multisim Component RC1k ##*
rRC1k CRes1k Collector 1000

.SUBCKT 2N7000_2__MOS_ENH_N__1 1 2 3
Cgs  2 3 12.3E-12
Cgd1 2 4 27.4E-12
Cgd2 1 4 6E-12
M1 1 2 3 3 MOST1 W=9.7m L=2u
M2 4 2 1 3 MOST2 W=9.7m L=2u
D1 3 1 Dbody
.MODEL MOST1 NMOS(Level=3 Kp=20.78u W=9.7m L=2u Rs=20m Vto=2 Rd=1.186)
.MODEL MOST2 NMOS(VTO=-4.73 Kp=20.78u W=9.7m L=2u Rs=20m)
.MODEL Dbody D(Is=125f N=1.023 Rs=1.281 Ikf=18.01 Cjo=46.3p M=.3423
+            Vj=.4519 Bv=60 Ibv=10u Tt=161.6n)
.ENDS

** C_switch **

*## Multisim Component RC6 ##*
rRC6 VDAC0mult 24 100000

*## Multisim Component Q8 ##*
xQ8 24 CVin10 0 ZVN0124__MOS_ENH_N__1

*## Multisim Component Q7 ##*
xQ7 CRes10 24 VDAC0mult NTA4151P/ON__MOS_ENH_P__1

.SUBCKT ZVN0124__MOS_ENH_N__1 3 4 5
*               D G S
M1 3 2 5 5 MN0124
RG 4 2 225
RL 3 5 2.4E7
D1 5 3 DN0124
.MODEL MN0124 NMOS VTO=1.5512 RS=1.436 RD=9.254 IS=1E-15 KP=1.077
+CGSO=60E-12 CGDO=2E-12 CBD=36E-12 PB=1 LAMBDA=0
.MODEL DN0124 D IS=3.071E-12 N=1.026 RS=0.511
.ENDS ZVN0124

.SUBCKT NTA4151P/ON__MOS_ENH_P__1  1 2 3
**************************************
*      Model Generated by MODPEX     *
*Copyright(c) Symmetry Design Systems*
*         All Rights Reserved        *
*    UNPUBLISHED LICENSED SOFTWARE   *
*   Contains Proprietary Information *
*      Which is The Property of      *
*     SYMMETRY OR ITS LICENSORS      *
*Commercial Use or Resale Restricted *
*   by Symmetry License Agreement    *
**************************************
* Model generated on Oct  4, 10
* MODEL FORMAT: PSpice
* Symmetry POWER MOS Model (Version 1.0)
* External Node Designations
* Node 1 -> Drain
* Node 2 -> Gate
* Node 3 -> Source
M1 9 7 8 8 MM L=100u W=100u
* Default values used in MM:
* The voltage-dependent capacitances are
* not included. Other default values are:
*   RS=0 RD=0 LD=0 CBD=0 CBS=0 CGBO=0
.MODEL MM PMOS LEVEL=1 IS=1e-32
+VTO=-0.868304 LAMBDA=0.0695331 KP=4.15322
+CGSO=1.37892e-06 CGDO=1.15666e-07
RS 8 3 0.165069
D1 1 3 MD
.MODEL MD D IS=9.46735e-09 RS=0.233288 N=1.5 BV=27.9
+IBV=0.00025 EG=1 XTI=1 TT=2.5e-09
+CJO=2.21746e-11 VJ=2.55501 M=0.749801 FC=0.5
RDS 3 1 1.33e+11
RD 9 1 0.0301336
RG 2 7 26.3891
D2 5 4 MD1
* Default values used in MD1:
*   RS=0 EG=1.11 XTI=3.0 TT=0
*   BV=infinite IBV=1mA
.MODEL MD1 D IS=1e-32 N=50
+CJO=6.92221e-11 VJ=0.5 M=0.9 FC=1e-08
D3 5 0 MD2
* Default values used in MD2:
*   EG=1.11 XTI=3.0 TT=0 CJO=0
*   BV=infinite IBV=1mA
.MODEL MD2 D IS=1e-10 N=0.4 RS=3.00001e-06
RL 5 10 1
FI2 7 9 VFI2 -1
VFI2 4 0 0
EV16 10 0 9 7 1
CAP 11 10 3.02409e-10
FI1 7 9 VFI1 -1
VFI1 11 6 0
RCAP 6 10 1
D4 6 0 MD3
* Default values used in MD3:
*   EG=1.11 XTI=3.0 TT=0 CJO=0
*   RS=0 BV=infinite IBV=1mA
.MODEL MD3 D IS=1e-10 N=0.4
.ENDS NTA4151P/ON

** C_switch **

*## Multisim Component RC8 ##*
rRC8 VDAC0mult 36 100000

*## Multisim Component Q6 ##*
xQ6 36 CVin1k 0 ZVN0124__MOS_ENH_N__1

*## Multisim Component Q5 ##*
xQ5 CRes1k 36 VDAC0mult NTA4151P/ON__MOS_ENH_P__1

** V_div **

*## Multisim Component U1 ##*
xU1 CRes10 43 12V -5V 43 OPA234/TI__OPAMP__1

*## Multisim Component Rm8 ##*
rRm8 CRes10Div 0 10000

*## Multisim Component Rm7 ##*
rRm7 CRes10Div 43 40000

* OPA234
*****************************************************************************
* (C) Copyright 2011 Texas Instruments Incorporated. All rights reserved.
*****************************************************************************
** This model is designed as an aid for customers of Texas Instruments.
** TI and its licensors and suppliers make no warranties, either expressed
** or implied, with respect to this model, including the warranties of
** merchantability or fitness for a particular purpose.  The model is
** provided solely on an "as is" basis.  The entire risk as to its quality
** and performance is with the customer.
*****************************************************************************
*
* This model is subject to change without notice. Texas Instruments
* Incorporated is not responsible for updating this model.
*
*****************************************************************************
*
** Released by: Analog eLab Design Center, Texas Instruments Inc.
* Part: OPA234
* Date: 01JUL2011
* Model Type: ALL IN ONE
* Simulator: PSPICE
* Simulator Version: 16.0.0.p001
* EVM Order Number: N/A
* EVM Users Guide: N/A
* Datasheet: SBOS055B ï¿½ MAY 1996 ï¿½ REVISED APRIL 2008
*
* Model Version: 1.0
*
*****************************************************************************
*
* Updates:
*
* Version 1.0 :
* Release to Web
*
*****************************************************************************
* This model is applicable to OPA234, OPA2234, OPA4234
* connections:   non-inverting input
*                | inverting input
*                | | positive power supply
*                | | | negative power supply
*                | | | | output
*                | | | | |
*****************************************************************************
.SUBCKT OPA234/TI__OPAMP__1   1 2 3 4 5
*
C1   11 12 6.995E-12
C2    6  7 30E-12
DC    5 53 DX
DE   54  5 DX
DLP  90 91 DX
DLN  92 90 DX
DP    4  3 DX
EGND 99  0 POLY(2) (3,0) (4,0) 0 .5 .5
FB    7 99 POLY(5) VB VC VE VLP VLN 0 479.3E6 -480E6 480E6 480E6 -480E6
GA    6  0 11 12 65.97E-6
GCM   0  6 10 99 1.046E-9
IEE   3 10 DC 6.100E-6
HLIM 90  0 VLIM 1E3
Q1   11  2 13 QX
Q2   12  64 14 QX
R2    6  9 100.0E3
RC1   4 11 15.16E3
RC2   4 12 15.16E3
RE1  13 10 6.429E3
RE2  14 10 6.429E3
REE  10 99 50.00E6
RO1   8  5 10
RO2   7 99 10
VB    9  0 DC 0
VC    3 53 DC 1.3
VE   54  4 DC 0.65
VLIM  7  8 DC 0
VLP  91 0 DC 10
VLN   0 92 DC 10
* Output Supply Mirror
DQ1   20    21    DX
DQ2   22    20    DX
VQ1   21     0    0
VQ2   22     0    0
*adds quiescent plus positive output current
FQ1    3     0    POLY(1) VQ1   235E-6   1
*adds quiescent plus negative output current
FQ2    0     4    POLY(1) VQ2   235E-6  -1
*mirrors output current-used by FQ1 and FQ2
FQ3    0    20    POLY(1) VLIM 0   1
* delta Quiescent Current / delta Supplies
*determines change in IQ with change in power supply voltages
RQ     3     4    1E6
* Diff Input Capacitance
CDIF   1     2    5E-12
* Common Mode Input Capacitance
C1CM   1    99    6E-12
C2CM   2    99    6E-12
* Input Voltage Noise
VN1   61     0  0.6
VN2    0    62  0.6
DN1   61    63  DY
DN2   63    62  DY
*adds 1/f noise to model. Adjusted to agree w/actual en
EN    64     1  63   0    0.8
RN1    0    65  60.3865
RN2   65    66  60.3865
RN3   66     0  120.773
RN4    0    67  60.3865
RN5   67    68  60.3865
RN6   68     0  120.773
**************************
.MODEL DX D(IS=800.0E-18)
*adds voltage noise
.MODEL DY D(IS=1.9E-16 RS=2000 AF=1 KF=2.258E-17)
.MODEL QX PNP(IS=800.0E-18 BF=60)
.ENDS OPA234/TI
*

** V_div **

*## Multisim Component U7 ##*
xU7 CRes1k 57 12V -5V 57 OPA234/TI__OPAMP__1

*## Multisim Component Rm6 ##*
rRm6 CRes1kDiv 0 10000

*## Multisim Component Rm5 ##*
rRm5 CRes1kDiv 57 40000

** V_div **

*## Multisim Component U8 ##*
xU8 Collector 64 12V -5V 64 OPA234/TI__OPAMP__1

*## Multisim Component Rm2 ##*
rRm2 CollectorDiv 0 10000

*## Multisim Component Rm1 ##*
rRm1 CollectorDiv 64 40000

** V_div **

*## Multisim Component U3 ##*
xU3 VDAC1mult 8 12V -5V 8 OPA234/TI__OPAMP__1

*## Multisim Component Rm10 ##*
rRm10 bres100div 0 10000

*## Multisim Component Rm9 ##*
rRm9 bres100div 8 40000

** V_div **

*## Multisim Component U5 ##*
xU5 base 10 12V -5V 10 OPA234/TI__OPAMP__1

*## Multisim Component Rm14 ##*
rRm14 basediv 0 10000

*## Multisim Component Rm13 ##*
rRm13 basediv 10 40000

** 2x multiplier DAC1 **

*## Multisim Component Q12 ##*
qQ12 -5V 6 VDAC1mult QBC51-10PA/NXP__BJT_PNP__1

*## Multisim Component Q11 ##*
qQ11 12V 6 VDAC1mult QBD135__BJT_NPN__1

*## Multisim Component RC9 ##*
rRC9 VDAC1mult 5 10000

*## Multisim Component RC5 ##*
rRC5 5 0 10000

*## Multisim Component U12 ##*
xU12 VDAC1 5 12V -5V 6 OPA234/TI__OPAMP__1

*
**********************************************************
*
* BC51-10PA
*
* NXP Semiconductors
*
* Medium power PNP transistor
* IC   = 1 A
* VCEO = 45 V
* hFE  = 63 - 160 @ 2V/150mA
*
*
*
* Package: SOT 1061
*
* Package Pin 1: Base
* Package Pin 2: Emitter
* Package Pin 3: Collector
*
*
*
* Simulator: Spice 2
*
**********************************************************
*#
.MODEL QBC51-10PA/NXP__BJT_PNP__1 PNP
+     IS=6.1530E-14
+     NF=0.9911
+     ISE=1.382E-16
+     NE=1.089
+     BF=150.8
+     IKF=1.225
+     VAF=105.4
+     NR=0.9965
+     ISC=6.480E-15
+     NC=1.022
+     BR=8.074
+     IKR=0.3627
+     VAR=18.20
+     RB=2
+     IRB=1E-06
+     RBM=2
+     RE=5.562E-02
+     RC=0.1449
+     XTB=0
+     EG=1.11
+     XTI=3
+     CJE=1.157E-10
+     VJE=0.7300
+     MJE=0.3751
+     TF=8.666E-10
+     XTF=1.231
+     VTF=3.008
+     ITF=0.4581
+     PTF=0
+     CJC=5.264E-11
+     VJC=0.6591
+     MJC=0.4533
+     XCJC=0.4401
+     TR=2.75E-07
+     CJS=0
+     VJS=0.75
+     MJS=0.333
+     FC=0.9427

.MODEL QBD135__BJT_NPN__1 NPN(
+ IS = 4.815E-14
+ NF = 0.9897
+ ISE = 1.389E-14
+ NE = 1.6
+ BF = 124.2
+ IKF = 1.6
+ VAF = 222
+ NR = 0.9895
+ ISC = 1.295E-13
+ NC = 1.183
+ BR = 13.26
+ IKR = 0.29
+ VAR = 81.4
+ RB = 0.5
+ IRB = 1E-06
+ RBM = 0.5
+ RE = 0.165
+ RC = 0.096
+ XTB = 0
+ EG = 1.11
+ XTI = 3
+ CJE = 1.243E-10
+ VJE = 0.7313
+ MJE = 0.3476
+ TF = 6.478E-10
+ XTF = 29
+ VTF = 2.648
+ ITF = 3.35
+ PTF = 0
+ CJC = 3.04E-11
+ VJC = 0.5642
+ MJC = 0.4371
+ TR = 1E-32
+ CJS = 0
+ VJS = 0.75
+ MJS = 0.333
+ FC = 0.9359 )

** DAC0 multiplication **

*## Multisim Component Q2 ##*
qQ2 12V 4 VDAC0mult QBD135__BJT_NPN__1

*## Multisim Component RC4 ##*
rRC4 VDAC0mult 3 10000

*## Multisim Component RC3 ##*
rRC3 3 0 10000

*## Multisim Component U2 ##*
xU2 VDAC0 3 12V -5V 4 OPA234/TI__OPAMP__1

** 0_5V_switch **

*## Multisim Component Q3 ##*
qQ3 -5V 2 Emitter QBC51-10PA/NXP__BJT_PNP__1

*## Multisim Component Q1 ##*
qQ1 12V 2 Emitter QBD135__BJT_NPN__1

*## Multisim Component U4 ##*
xU4 VpwrPin Emitter 12V -5V 2 OPA234/TI__OPAMP__1

** V_div **

*## Multisim Component U6 ##*
xU6 Emitter 11 12V -5V 11 OPA234/TI__OPAMP__1

*## Multisim Component Rm4 ##*
rRm4 EmitterDIV 0 10000

*## Multisim Component Rm3 ##*
rRm3 EmitterDIV 11 40000

.PARAM DAC0Param=4.8840049
.PARAM DAC1Param=2
.PARAM DigCVin1kParam=IF(CRes==0,5,0)
.PARAM DigCVin10Param=IF(CRes==1,5,0)
.PARAM CRes=1
.PARAM EpwrPinParam=IF(EpwrPin==1,5,0)
.PARAM EpwrPin=0

.OP
.OPT noOpiter GminSteps=0
.SAVE V(vdac1) V(vdac1mult) V(base) I(Rrb100) V(vdac0) V(vdac0mult) Ie(Qq2) V(cvin1k) V(cvin10) V(cres1k) V(cres10) V(collector) I(Rrc1k) I(Rrc10) V(bres100div) V(cres1kdiv) V(cres10div) V(collectordiv) V(basediv) V(emitter) V(emitterdiv) V(vpwrpin) Ie(Qq1) Ie(Qq3)
.end
