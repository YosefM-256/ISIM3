** DC circuit - 3 **
*
* NI Multisim to SPICE Netlist Export
* Generated by: mizra
* Tue, Mar 28, 2023 11:42:29
*

*## Multisim Component DUT ##*
qDUT Emitter base Collector 2N3906__BJT_PNP__1

*## Multisim Component RC1k ##*
rRC1k CRes1k Collector 1000

*## Multisim Component 0_5V_PWR ##*
v0_5V_PWR VpwrPin 0 dc {EpwrPinParam} ac 0 0

*## Multisim Component DAC1 ##*
vDAC1 VDAC1 0 dc {DAC1Param} ac 0 0

*## Multisim Component DigCVin10 ##*
vDigCVin10 CVin10 0 dc {DigCVin10Param} ac 0 0

*## Multisim Component DigCVin1k ##*
vDigCVin1k CVin1k 0 dc {DigCVin1kParam} ac 0 0

*## Multisim Component RB100 ##*
rRB100 VDAC1mult base 100

*## Multisim Component V15 ##*
vV15 -3.3 0 dc -3.3 ac 0 0

*## Multisim Component V14 ##*
vV14 12V 0 dc 12 ac 0 0

*## Multisim Component DAC0 ##*
vDAC0 VDAC0 0 dc {DAC0Param} ac 0 0

*## Multisim Component RC10 ##*
rRC10 CRes10 Collector 10

*
**********************************************************
*
* BC846BMB
*
* NXP Semiconductors
*
* 2 NPN transistors
* IC   = 100 mA
* VCEO = 65 V
* hFE  = 200 - 450 @ 5V/2mA
*
*
*
*
* Package pinning does not match Spice model pinning.
* Package: SOT 883B
*
* Package Pin 1: Base
* Package Pin 2: Emitter
* Package Pin 3: Collector
*
*
* Extraction date (week/year): 09/2002
* Simulator: Spice 2
*
**********************************************************
*#
* Please note: The following model is to be used twice in
* schematic due to equality of both transistors.
*
*

.MODEL 2N3906__BJT_PNP__1   PNP(Is=1.41f Xti=3 Eg=1.11 Vaf=18.7 Bf=180.7 Ne=1.5 Ise=0
+               Ikf=80m Xtb=1.5 Br=4.977 Nc=2 Isc=0 Ikr=0 Rc=2.5 Cjc=9.728p
+               Mjc=.5776 Vjc=.75 Fc=.5 Cje=8.063p Mje=.3677 Vje=.75 Tr=33.42n
+               Tf=179.3p Itf=.4 Vtf=4 Xtf=6 Rb=10)

** C_switch **

*## Multisim Component Q8 ##*
xQ8 24 CVin10 0 2N7000/ON__MOS_ENH_N__1

*## Multisim Component Q7 ##*
xQ7 CRes10 24 VDAC0mult PMF170XP/NXP__MOS_ENH_P__1

*## Multisim Component RC6 ##*
rRC6 VDAC0mult 24 100000

.SUBCKT 2N7000/ON__MOS_ENH_N__1 1 2 3
**************************************
*      Model Generated by MODPEX     *
*Copyright(c) Symmetry Design Systems*
*         All Rights Reserved        *
*    UNPUBLISHED LICENSED SOFTWARE   *
*   Contains Proprietary Information *
*      Which is The Property of      *
*     SYMMETRY OR ITS LICENSORS      *
*Commercial Use or Resale Restricted *
*   by Symmetry License Agreement    *
**************************************
* Model generated on Mar 31, 04
* MODEL FORMAT: PSpice
* Symmetry POWER MOS Model (Version 1.0)
* External Node Designations
* Node 1 -> Drain
* Node 2 -> Gate
* Node 3 -> Source
M1 9 7 8 8 MM L=100u W=100u
* Default values used in MM:
* The voltage-dependent capacitances are
* not included. Other default values are:
*   RS=0 RD=0 LD=0 CBD=0 CBS=0 CGBO=0
.MODEL MM NMOS LEVEL=1 IS=1e-32
+VTO=2.236 LAMBDA=0 KP=0.0932174
+CGSO=1.79115e-07 CGDO=1.0724e-11
RS 8 3 1.10523
D1 3 1 MD
.MODEL MD D IS=2.71011e-10 RS=0.0140826 N=1.5 BV=60
+IBV=1e-05 EG=1.16084 XTI=3.00131 TT=0
+CJO=3.41211e-11 VJ=4.67429 M=0.899864 FC=0.1
RDS 3 1 2.4e+11
RD 9 1 0.0001
RG 2 7 2.18034
D2 4 5 MD1
* Default values used in MD1:
*   RS=0 EG=1.11 XTI=3.0 TT=0
*   BV=infinite IBV=1mA
.MODEL MD1 D IS=1e-32 N=50
+CJO=7.93181e-11 VJ=0.643298 M=0.9 FC=1e-08
D3 0 5 MD2
* Default values used in MD2:
*   EG=1.11 XTI=3.0 TT=0 CJO=0
*   BV=infinite IBV=1mA
.MODEL MD2 D IS=1e-10 N=0.400165 RS=3.00002e-06
RL 5 10 1
FI2 7 9 VFI2 -1
VFI2 4 0 0
EV16 10 0 9 7 1
CAP 11 10 1.58786e-10
FI1 7 9 VFI1 -1
VFI1 11 6 0
RCAP 6 10 1
D4 0 6 MD3
* Default values used in MD3:
*   EG=1.11 XTI=3.0 TT=0 CJO=0
*   RS=0 BV=infinite IBV=1mA
.MODEL MD3 D IS=1e-10 N=0.400165
.ENDS 2N7000/ON

*****************************************************************
* NXP PMF170XP
*
* Polarity P-Channel
* Ratings 20V/2.000000E-001OHMS/1A
*
* Date Created Mon Jun 27 01:21:53 2011
*
*****************************************************************
*
*****************************************************************
.SUBCKT PMF170XP/NXP__MOS_ENH_P__1 DRAIN GATE SOURCE
LD DRAIN 5 4e-10
RLD2 DRAIN 5 1.00530964914873
RLD1 5 4 0.0028
LG GATE 1 8.81711084834576e-10
RLG GATE 1 2.21598165336399
LS SOURCE 8 1.48299790790991e-09
RLS2 SOURCE 8 3.72718026622305
RLS1 8 7 0.0565513610286835
RDS 7 4 40000000000 TC=-0.05
RS 6 7 0.0001
RD 3 4 0.0629616671665268 TC=0.0210621477432937,-0.000144692600922005
RBD 9 4 0.0607319236153256 TC=0.0210621477432937,-0.000144692600922005
DBD 9 7 DBD
M1 3 2 6 6 MINT
RGS 2 6 120000000000
CGS 2 6 2.56e-10
RG 1 2 16.9470486389713
* CGD
C11    11   12   1E-12
V11    11   0   0Vdc
G11    2 3 VALUE { V(13, 0)*I(V11) }
E11    12   0  2 3  1
E12    13   0  TABLE {V(12)}
+ -8	4.34
+ -6	6.17
+ -5	6.39
+ -4	6.79
+ -3	8.55
+ -2	26.31
+ -1	49.34
+ -0.5	63.85
+ -0.2	77.34
+ -0.1	83.38
+ 0	88.18
+ 0.1	78.5
+ 0.2	73
+ 0.5	61.3
+ 1	50
+ 2	41.6
+ 3	37.7
+ 4	35.2
+ 5	33.6
+ 6	32.3
+ 8	30.4
+ 10	29
+ 12	28
+ 15	26.5
+ 20	24.9
*.MODEL MINT PMOS(Vto=-1.12809317523724 Kp=6.651452e+000 Nfs=320000000000 Eta=0
.MODEL MINT PMOS(Vto=-1.13809317523724 Kp=6.651452e+000 Nfs=920000000000 Eta=0
+ Level=3 L=1e-4 W=1e-4 Gamma=0 Phi=0.6 Is=1e-24
+ Js=0 Pb=0.8 Cj=0 Cjsw=0 Cgso=0 Cgdo=0 Cgbo=0
+ Tox=1e-07 Xj=0
+ U0=600 Vmax=5000)
*+ U0=600 Vmax=1000)
.MODEL DBD D(Bv=25 Ibv=2.500000E-004 Rs=1E-6 Is=3.80150013851312e-13
+ N=1 M=0.48 VJ=0.64 Fc=0.5 Cjo=4.38e-11 Tt=1.85e-08)
.ENDS

** C_switch **

*## Multisim Component Q6 ##*
xQ6 36 CVin1k 0 2N7000/ON__MOS_ENH_N__1

*## Multisim Component Q5 ##*
xQ5 CRes1k 36 VDAC0mult PMF170XP/NXP__MOS_ENH_P__1

*## Multisim Component RC8 ##*
rRC8 VDAC0mult 36 100000

** V_div **

*## Multisim Component U3 ##*
xU3_A CRes10 43 43 NJM4565__OPAMP__1

*## Multisim Component Rm8 ##*
rRm8 CRes10Div 0 10000

*## Multisim Component Rm7 ##*
rRm7 CRes10Div 43 40000

.SUBCKT NJM4565__OPAMP__1 1 2 3
* EWB Version 4 - 3 Terminal Opamp Model
* A= 100000 RI= 300000 RO= 75 VSW+= 14 VSW-= -14
* Vos= 0.0005 Ibs= 5e-008 Ios= 2e-009 SR+= 4e+006
* fu= 1e+007 fp2= 1e+032 CC= 3e-011
    Vos 4 1 DC 0.0005V
    Ib1 4 0 5.1e-008A
    Ib2 2 0 4.9e-008A
    G1 0 5 4 2 0.0464159
    G2 0 6 5 0 0.618879
    G3 0 3 6 0 0.618879
    Ri 4 2 300000ohm
    R1 5 0 1000ohm
    R2 6 0 75ohm
    R3 3 0 75ohm
    C1 5 0 1.59155e-006
    C2 6 0 2.12207e-035
    Cc 5 0 3e-011
.ENDS

** V_div **

*## Multisim Component U5 ##*
xU5_A CRes1k 57 57 NJM4565__OPAMP__1

*## Multisim Component Rm6 ##*
rRm6 CRes1kDiv 0 10000

*## Multisim Component Rm5 ##*
rRm5 CRes1kDiv 57 40000

** V_div **

*## Multisim Component U1 ##*
xU1_A Collector 64 64 NJM4565__OPAMP__1

*## Multisim Component Rm2 ##*
rRm2 CollectorDiv 0 10000

*## Multisim Component Rm1 ##*
rRm1 CollectorDiv 64 40000

** V_div **

*## Multisim Component U6 ##*
xU6_A VDAC1mult 8 8 NJM4565__OPAMP__1

*## Multisim Component Rm10 ##*
rRm10 bres100div 0 10000

*## Multisim Component Rm9 ##*
rRm9 bres100div 8 40000

** V_div **

*## Multisim Component U7 ##*
xU7_A base 10 10 NJM4565__OPAMP__1

*## Multisim Component Rm14 ##*
rRm14 basediv 0 10000

*## Multisim Component Rm13 ##*
rRm13 basediv 10 40000

** 2x multiplier DAC1 **

*## Multisim Component Q11 ##*
xQ11 12V 1 VDAC1mult PMV30UN/NXP__MOS_ENH_N__1

*## Multisim Component U4 ##*
xU4 VDAC1 5 12V -3.3 1 U4_OPEN_BAL1 U4_OPEN_COMP LM301A__OPAMP__1

*## Multisim Component Q3 ##*
xQ3 0 1 VDAC1mult BSH207/NXP__MOS_ENH_P__1

*## Multisim Component RC9 ##*
rRC9 VDAC1mult 5 10000

*## Multisim Component RC5 ##*
rRC5 5 0 10000

*****************************************************************
* NXP pmv30un
*
* Polarity N-Channel
* Ratings 20V/2.97E-02OHMS/5A
*
* Date Created Fri Nov 23 01:28:35 2007
*
*****************************************************************
*
*****************************************************************
.SUBCKT PMV30UN/NXP__MOS_ENH_N__1 DRAIN GATE SOURCE
LD DRAIN 5 4e-10
RLD2 DRAIN 5 1.0053088
RLD1 5 4 0.0023
LG GATE 1 7.81292696075128e-10
RLG GATE 1 1.96360105685013
LS SOURCE 8 6.88776498943078e-10
RLS2 SOURCE 8 1.73108268905167
RLS1 8 7 0.00836612880521089
RDS 7 4 400000000 TC=-0.05
RS 6 7 0.0001
RD 3 4 0.0148078287036714 TC=0.00766938953329671,6.45562944572843e-06
RBD 9 4 0.0130999395994052 TC=0.00766938953329671,6.45562944572843e-06
DBD 7 9 DBD
M1 3 2 6 6 MINT
RGS 2 6 400000000000
CGS 2 6 6.73853543307087e-10
RG 1 2 1.49060161358437
* CGD
C11    11   12   1E-12
V11    11   0   0Vdc
G11    3 2 VALUE { V(13, 0)*I(V11) }
E11    12   0  3 2  1
E12    13   0  TABLE {V(12)}
+ -10	1042
+ -5	1042
+ -4	1044
+ -3	1048
+ -2	1052
+ -1	1298
+ -0.5	1104
+ -0.2	908
+ -0.1	845
+ 0	772.5
+ 0.1	697
+ 0.2	615
+ 0.5	411
+ 1	284
+ 2	208
+ 5	141
+ 10	105.3
+ 12	97.8
+ 20	80
.MODEL MINT NMOS(Vto=0.824178043761067 Kp=6.6743e+01 Nfs=130000000000 Eta=0
+ Level=3 L=1e-4 W=1e-4 Gamma=0 Phi=0.6 Is=1e-24
+ Js=0 Pb=0.8 Cj=0 Cjsw=0 Cgso=0 Cgdo=0 Cgbo=0
+ Tox=1e-07 Xj=0
+ U0=600 Vmax=1000)
.MODEL DBD D(Bv=22.40 Ibv=2.50E-04 Rs=1E-6 Is=2.74679912046058e-11
+ N=1 M=0.52 VJ=0.5 Fc=0.5 Cjo=1.7e-10 Tt=2.44e-08)
.ENDS

* NODES 1 AND 8 = COMPENSATION PINS
*
.SUBCKT LM301A__OPAMP__1 3 2 7 4 6 1 8
* USE C=30 PF IN MAIN CIRCUIT (CA TO CB).
* INPUT
RC1 7 80 5895
RC2 7 90 5895
Q1 80 2 10 QM1
Q2 90 3 11 QM2
C1 80 90 5.46e-12
RE1 10 12 2438
RE2 11 12 2438
IEE 12 4 1.506e-5
RE 12 0 13280000
CE 12 0 1.579E-12
* INTERMEDIATE
GCM 0 8 12 0 2.689e-9
GA 8 0 80 90 1.696E-04
R2 8 0 100000
* EXTERNAL COMP CAP USED FOR C2 (SEE NOTE ABOVE).
GB 1 0 8 0 140.1
* OUTPUT
RO1 1 6 33.33
RO2 1 0 66.67
RC 17 0 4.758e-5
GC 0 17 6 0 21020
D1 1 17 DM1
D2 17 1 DM1
D3 6 13 DM2
D4 14 6 DM2
VC 7 13 1.808
VE 14 4 1.808
IP 7 4 0.001785
DSUB 4 7 DM2
* MODELS
.MODEL QM1 NPN(IS=8e-16 BF=104.9)
.MODEL QM2 NPN(IS=8.647E-16 BF=109.5)
.MODEL DM1 D(IS=3.337E-15)
.MODEL DM2 D(IS=8e-16)
.ENDS LM301A
*

*****************************************************************
* NXP BSH207
*
* Polarity P-Channel
* Ratings 12V/8.000000E-002OHMS/1.52A
*
* Date Created Wed May 30 03:46:22 2012
*
*****************************************************************
*
*****************************************************************
.SUBCKT BSH207/NXP__MOS_ENH_P__1 DRAIN GATE SOURCE
LD DRAIN 5 1e-10
RLD2 DRAIN 5 0.251327412287183
RLD1 5 4 0.0006
LG GATE 1 7.26405326934776e-10
RLG GATE 1 1.82565571090143
LS SOURCE 8 1.01346117276679e-09
RLS2 SOURCE 8 2.54710574005012
RLS1 8 7 0.00910225399683472
RDS 7 4 738461.538461539 TC=-0.005
RS 6 7 0.0001
RD 3 4 0.0384103867090102 TC=-0.0023299770421971,-8.11311718671506E-06
RBD 9 4 0.0520154189280158 TC=-0.0023299770421971,-8.11311718671506E-06
DBD 9 7 DBD
M1 3 2 6 6 MINT
RGS 2 6 800000000
CGS 2 6 1.36909e-10
RG 1 2 0.988795492006331
* CGD
C11    11   12   1E-12
V11    11   0   0Vdc
G11    2 3 VALUE { V(13, 0)*I(V11) }
E11    12   0  2 3  1
E12    13   0  TABLE {V(12)}
+ -12	478.819
+ -10	479.463
+ -8	480.128
+ -6	481.158
+ -5	481.919
+ -4	482.973
+ -3	484.641
+ -2	488.293
+ -1	519.508
+ -0.5	581.897
+ -0.2	531.882
+ -0.1	530.421
+ 0	483.8395
+ 0.1	420.652
+ 0.2	420.2
+ 0.5	307.154
+ 1	202.975
+ 2	140.739
+ 3	117.642
+ 4	104.539
+ 5	95.4427
+ 6	88.8774
+ 8	80.0221
+ 10	74.1818
+ 12	69.9755
.MODEL MINT PMOS(Vto=-0.610548146261887 Kp=8.002089e+000 Nfs=100000 Eta=1000
+ Level=3 L=1e-4 W=1e-4 Gamma=0 Phi=0.6 Is=1e-24
+ Js=0 Pb=0.8 Cj=0 Cjsw=0 Cgso=0 Cgdo=0 Cgbo=0
+ Tox=1e-07 Xj=0
+ U0=600 Vmax=200000)
.MODEL DBD D(Bv=22.9 Ibv=1.000000E-005 Rs=1E-6 Is=5.87670518801215e-10
+ N=1 M=0.41 VJ=0.5 Fc=0.5 Cjo=5.23798e-10 Tt=1.85e-08)
.ENDS

** DAC0 multiplication **

*## Multisim Component Q2 ##*
qQ2 12V 4 VDAC0mult QBD135__BJT_NPN__1

*## Multisim Component U2 ##*
xU2 VDAC0 3 12V -3.3 4 U2_OPEN_BAL1 U2_OPEN_COMP LM301A__OPAMP__1

*## Multisim Component RC4 ##*
rRC4 VDAC0mult 3 10000

*## Multisim Component RC3 ##*
rRC3 3 0 10000

.MODEL QBD135__BJT_NPN__1 NPN(
+ IS = 4.815E-14
+ NF = 0.9897
+ ISE = 1.389E-14
+ NE = 1.6
+ BF = 124.2
+ IKF = 1.6
+ VAF = 222
+ NR = 0.9895
+ ISC = 1.295E-13
+ NC = 1.183
+ BR = 13.26
+ IKR = 0.29
+ VAR = 81.4
+ RB = 0.5
+ IRB = 1E-06
+ RBM = 0.5
+ RE = 0.165
+ RC = 0.096
+ XTB = 0
+ EG = 1.11
+ XTI = 3
+ CJE = 1.243E-10
+ VJE = 0.7313
+ MJE = 0.3476
+ TF = 6.478E-10
+ XTF = 29
+ VTF = 2.648
+ ITF = 3.35
+ PTF = 0
+ CJC = 3.04E-11
+ VJC = 0.5642
+ MJC = 0.4371
+ TR = 1E-32
+ CJS = 0
+ VJS = 0.75
+ MJS = 0.333
+ FC = 0.9359 )

** 0_5V_switch **

*## Multisim Component U9 ##*
xU9 VpwrPin Emitter 12V -3.3 15 U9_OPEN_BAL1 U9_OPEN_COMP LM301A__OPAMP__1

*## Multisim Component Q4 ##*
xQ4 0 15 Emitter BSH207/NXP__MOS_ENH_P__1

*## Multisim Component Q9 ##*
xQ9 0 15 Emitter BSH207/NXP__MOS_ENH_P__1

** V_div **

*## Multisim Component U8 ##*
xU8_A Emitter 11 11 NJM4565__OPAMP__1

*## Multisim Component Rm4 ##*
rRm4 EmitterDIV 0 10000

*## Multisim Component Rm3 ##*
rRm3 EmitterDIV 11 40000

.PARAM DAC0Param=0.94749695
.PARAM DAC1Param=0
.PARAM DigCVin1kParam=IF(CRes==0,5,0)
.PARAM DigCVin10Param=IF(CRes==1,5,0)
.PARAM CRes=1
.PARAM EpwrPinParam=IF(EpwrPin==1,5,0)
.PARAM EpwrPin=1

.OP
.OPT noOpiter GminSteps=0
.SAVE V(vdac1) V(vdac1mult) V(base) I(Rrb100) Ic(Qdut) Ib(Qdut) Ie(Qdut) V(vdac0) V(vdac0mult) Ie(Qq2) V(cvin1k) V(cvin10) V(cres1k) V(cres10) V(collector) I(Rrc1k) I(Rrc10) V(bres100div) V(cres1kdiv) V(cres10div) V(collectordiv) V(basediv) V(emitter) V(emitterdiv) V(vpwrpin)
.end
